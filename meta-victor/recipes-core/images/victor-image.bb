SUMMARY = "TESTE PRODUCAO DE IMAGEM"

IMAGE_FEATURES +="splash"

LICENSE = "MIT"

inherit core-image

CORE_IMAGE_EXTRA_INSTALL = "openssl apache2 php"

